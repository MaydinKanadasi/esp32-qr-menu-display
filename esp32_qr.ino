#include <Adafruit_GFX.h>
#include <Adafruit_ILI9341.h>

#define TFT_CS 15
#define TFT_DC 2

Adafruit_ILI9341 tft = Adafruit_ILI9341(TFT_CS, TFT_DC);

const int qrSize = 21;

byte qr[21][21] = {
{1,1,1,1,1,1,1,0,0,0,1,1,1,0,1,1,1,1,1,1,1},
{1,0,0,0,0,0,1,0,1,0,1,0,0,0,1,0,0,0,0,0,1},
{1,0,1,1,1,0,1,0,1,0,1,0,1,1,1,0,1,1,1,0,1},
{1,0,1,1,1,0,1,0,0,0,1,0,1,1,1,0,1,1,1,0,1},
{1,0,1,1,1,0,1,0,1,1,1,0,1,1,1,0,1,1,1,0,1},
{1,0,0,0,0,0,1,0,1,0,1,0,0,0,1,0,0,0,0,0,1},
{1,1,1,1,1,1,1,0,1,0,1,1,1,1,1,1,1,1,1,1,1},
{0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0},
{1,1,0,0,1,1,1,0,1,0,1,0,1,1,0,0,1,0,1,1,0},
{0,1,1,1,0,0,1,0,0,0,1,0,0,1,0,1,0,1,0,1,0},
{1,0,1,0,1,0,1,1,1,1,1,0,1,0,1,0,1,0,1,0,1},
{1,0,1,0,1,0,1,0,0,0,1,0,1,0,1,0,1,0,1,0,1},
{0,1,0,1,0,1,0,1,1,1,0,1,0,1,0,1,0,1,0,1,0},
{0,0,1,0,1,0,0,0,0,0,0,0,1,0,1,0,0,0,1,0,0},
{1,1,1,1,0,1,1,0,1,0,1,0,1,1,1,0,1,1,1,1,0},
{1,0,0,0,1,0,1,0,0,0,1,0,1,0,0,0,1,0,0,0,1},
{1,0,1,1,0,1,0,1,1,1,0,1,0,1,1,1,0,1,1,0,1},
{1,0,1,1,0,1,0,0,0,0,0,0,0,1,1,1,0,1,1,0,1},
{1,0,1,1,0,1,1,1,1,1,1,1,0,1,1,1,0,1,1,0,1},
{1,0,0,0,1,0,0,0,0,0,0,0,1,0,0,0,1,0,0,0,1},
{1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1}
};

void setup() {

  tft.begin();
  tft.setRotation(1);
  tft.fillScreen(ILI9341_WHITE);

  tft.setTextColor(ILI9341_BLACK);
  tft.setTextSize(3);
  tft.setCursor(30,10);
  tft.println("XXXX Restaurant");

  tft.setTextSize(2);
  tft.setCursor(100,210);
  tft.println("Masa YYY");

  int scale = 6;
  int offsetX = 80;
  int offsetY = 40;

  for(int y=0;y<qrSize;y++){
    for(int x=0;x<qrSize;x++){

      if(qr[y][x]==1){
        tft.fillRect(offsetX + x*scale,
                     offsetY + y*scale,
                     scale,
                     scale,
                     ILI9341_BLACK);
      }

    }
  }

}

void loop() {}
